# Keil uVision project TempStirV1.0.uvprojx, settings and files
target TempStirV1.0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: TempStirV1_0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../MDK-ARM/freertos;../MDK-ARM/freertos/inc;../MDK-ARM/freertos/port;../MDK-ARM/User/Inc;../MDK-ARM/User/App;../MDK-ARM/User/Int;../MDK-ARM/User/Utils;../MDK-ARM/User/Menu
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_can.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Application/User/App
    User/App/: App_Buzzer.c App_SysTem.c App_Fan.c App_Motor.c App_Encoder.c App_ADC.c App_Heat.c
  group Application/User/Int
    User/Int/: bsp_i2c1.c bsp_i2c2.c
  group Application/User/Utils
    User/Utils/: drv_m24c02.c driver_ssd1315.c
  group Application/User/Menu
    User/Menu/: App_Oled.c App_Key.c
  group Middlewares/FreeRTOS_Kernel
    freertos/src/: tasks.c queue.c list.c timers.c event_groups.c stream_buffer.c croutine.c
    freertos/port/: port.c heap_4.c
software components: CMSIS:CORE 4.3.0
